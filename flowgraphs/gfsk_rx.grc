options:
  parameters:
    author: 'AK '
    category: Custom
    description: GFSK Receiver for HackRF — 9600 baud, h=1.5
    generate_options: qt_gui
    id: gfsk_rx
    output_language: python
    realtime_scheduling: '1'
    title: GFSK Receiver - HackRF - 9600 baud
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF sample rate
    value: '2400000'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    comment: Symbol rate
    value: '9600'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol after decimation = 480000/9600 = 50
    value: '50'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Offset 100kHz from TX to avoid HackRF DC spike
    value: 433.1e6
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: h=0.6 → fd = 0.6*9600/2 = 2880 Hz
    value: '2880'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 'LPF decimation: 2400000/5 = 480000'
    value: '5'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Post-decimation rate
    value: samp_rate / decim
  states: {}
- name: encoded_frame_bits
  id: variable
  parameters:
    comment: 510 packed bytes = 4080 bits
    value: '4080'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: RF Gain (dB)
    start: '0'
    step: '14'
    stop: '62'
    value: '42'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: IF Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,2,1,1]'
    label: BB Gain (dB)
    start: '0'
    step: '2'
    stop: '62'
    value: '30'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: bb_gain
    center_freq0: center_freq
    comment: HackRF RX
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    type: fc32
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: Shift signal from -100kHz to baseband — avoids HackRF DC spike
    phase_inc: 2*math.pi*100000/samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: LPF + decimate 2.4M → 480k. Signal is at 0Hz after rotator.
    cutoff_freq: '50000'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '15000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM discriminator — gain = audio_rate/(2*pi*fd)
    gain: audio_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: Remove frequency offset — averages over many symbols
    length: '5000'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Mueller-Muller clock recovery — 9600 baud, sps=50
    damping: '1.0'
    loop_bw: '0.015'
    max_dev: '0.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    sub_type: '"float_to_float"'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_frame_sync
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import sys
      from gnuradio import gr

      class frame_sync(gr.basic_block):
          """Finds ASM 0xD87112BD — outputs frames to queue, drains to output."""
          def __init__(self, frame_nbits=4080, threshold=10):
              gr.basic_block.__init__(self,
                  name='Frame Sync',
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              asm_str = '11011000011100010001001010111101'
              self.asm_bits = np.array([int(b) for b in asm_str], dtype=np.uint8)
              self.asm_inv = 1 - self.asm_bits
              self.asm_len = 32
              self.frame_nbits = frame_nbits
              self.threshold = threshold
              self.packet_len = self.asm_len + self.frame_nbits
              self.inbuf = np.array([], dtype=np.float32)
              self.outqueue = np.array([], dtype=np.float32)
              self.frames_found = 0
              self.log = open('C:/gfsk/frame_sync_log.txt', 'w')
              self.log.write('Frame sync v2 started\n')
              self.log.flush()

          def forecast(self, noutput_items, ninputs):
              if len(self.outqueue) > 0:
                  return [0]
              return [self.packet_len]

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              self.inbuf = np.concatenate([self.inbuf, inp])
              self.consume(0, len(inp))
              if len(self.inbuf) > 500000:
                  self.inbuf = self.inbuf[-self.packet_len*4:]
              while len(self.inbuf) >= self.packet_len:
                  hard = (self.inbuf[:self.asm_len] > 0).astype(np.uint8)
                  score_n = int(np.sum(hard == self.asm_bits))
                  score_i = int(np.sum(hard == self.asm_inv))
                  if score_n >= self.asm_len - self.threshold:
                      frame = self.inbuf[self.asm_len:self.asm_len+self.frame_nbits].copy()
                      self.outqueue = np.concatenate([self.outqueue, frame])
                      self.inbuf = self.inbuf[self.packet_len:]
                      self.frames_found += 1
                      self.log.write(f'FOUND #{self.frames_found} normal score={score_n} outq={len(self.outqueue)}\n')
                      self.log.flush()
                  elif score_i >= self.asm_len - self.threshold:
                      frame = -self.inbuf[self.asm_len:self.asm_len+self.frame_nbits].copy()
                      self.outqueue = np.concatenate([self.outqueue, frame])
                      self.inbuf = self.inbuf[self.packet_len:]
                      self.frames_found += 1
                      self.log.write(f'FOUND #{self.frames_found} inverted score={score_i} outq={len(self.outqueue)}\n')
                      self.log.flush()
                  else:
                      self.inbuf = self.inbuf[1:]
                      break
              n_out = min(len(self.outqueue), len(out))
              if n_out > 0:
                  out[:n_out] = self.outqueue[:n_out]
                  self.outqueue = self.outqueue[n_out:]
              return int(n_out)
    comment: Finds ASM 0xD87112BD, threshold=10 bit errors allowed
    frame_nbits: encoded_frame_bits
    threshold: '10'
  states: {}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters:
    comment: Viterbi decoder — 4080 soft bits → 255 bytes
  states: {}
- name: epy_block_rs_decode
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class rs_decode(gr.basic_block):
          """RS(255,223) decoder. Skips 4 tail bytes, extracts 223 data bytes."""
          def __init__(self):
              gr.basic_block.__init__(self,
                  name='RS(255,223) Decode',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.rs_total = 255
              self.rs_data = 223
              self.tail = 4
              self.buf = np.array([], dtype=np.uint8)

          def forecast(self, noutput_items, ninputs):
              n_frames = max(1, noutput_items // self.rs_data)
              return [n_frames * self.rs_total]

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              self.buf = np.concatenate([self.buf, inp])
              self.consume(0, len(inp))
              out_idx = 0
              while len(self.buf) >= self.rs_total and out_idx + self.rs_data <= len(out):
                  frame = self.buf[:self.rs_total]
                  self.buf = self.buf[self.rs_total:]
                  out[out_idx:out_idx+self.rs_data] = frame[self.tail:self.tail+self.rs_data]
                  out_idx += self.rs_data
              return out_idx
    comment: Strips tail + parity, outputs 223 data bytes per frame
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    comment: Raw hard bits from symbol sync — for debugging
    file: gfsk_rx_raw_bits.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Decoded telemetry output
    file: gfsk_rx_output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: '[1,0,1,1]'
    label1: RX Signal
    name: '"RX Spectrum"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: '[2,0,1,1]'
    name: '"RX Waterfall"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    grid: 'True'
    gui_hint: '[1,1,1,1]'
    label1: Demod Bits
    name: '"Demodulated Bits"'
    size: '1024'
    srate: baud_rate
    type: float
    ymax: '2.0'
    ymin: '-2.0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"red"'
    comment: RAW demod output — should show +-1 square wave
    grid: 'True'
    gui_hint: '[2,1,1,1]'
    label1: Demod Signal
    name: '"Demod Signal (pre-sync)"'
    size: '5000'
    srate: audio_rate
    type: float
    ymax: '3.0'
    ymin: '-3.0'
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', dc_blocker_xx_0, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_frame_sync, '0']
- [epy_block_frame_sync, '0', fec_decode_ccsds_27_fb_0, '0']
- [fec_decode_ccsds_27_fb_0, '0', epy_block_rs_decode, '0']
- [epy_block_rs_decode, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
