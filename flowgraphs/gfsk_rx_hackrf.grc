options:
  parameters:
    author: 'AK '
    category: Custom
    description: GFSK RX HackRF — CCSDS compatible with FEC decode
    generate_options: qt_gui
    id: gfsk_rx_hackrf
    output_language: python
    realtime_scheduling: '1'
    title: GFSK RX - HackRF (CCSDS)
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Must match TX samp_rate
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Must match TX sps — baud = samp_rate/sps = 500 kbaud
    value: '4'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Must match TX center_freq
    value: 433e6
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: h=0.5 → 125 kHz deviation — must match TX
    value: '125000'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    comment: Must match TX sensitivity
    value: 2 * math.pi * fsk_deviation / samp_rate
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: CCSDS ASM 0x1ACFFC1D — standard for cFS/OpenC3
    value: '"00011010110011111111110000011101"'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: HackRF LNA gain (0-40, step 8)
    value: '32'
  states: {}
- name: if_gain
  id: variable
  parameters:
    comment: HackRF IF/VGA gain (0-62, step 2)
    value: '32'
  states: {}
- name: bb_gain
  id: variable
  parameters:
    comment: HackRF baseband gain
    value: '20'
  states: {}
- name: rx_gain_slider
  id: qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: LNA Gain (0-40 step 8)
    min_len: '200'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: rx_gain
    widget: counter_slider
  states: {}
- name: if_gain_slider
  id: qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: IF/VGA Gain (0-62 step 2)
    min_len: '200'
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: if_gain
    widget: counter_slider
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    comment: HackRF RX — uses variables for all params
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
    vga: if_gain
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: LPF cutoff=400kHz — passes h=0.5 GFSK (BW ~750kHz)
    cutoff_freq: '400000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    comment: GFSK Demod — outputs unpacked bits (1 bit/byte)
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: sensitivity
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: sync_word
    comment: |-
      Finds CCSDS ASM 0x1ACFFC1D in bitstream
      Tags 4080 unpacked bits (510 encoded bytes) as one frame
      Threshold=2 allows up to 2 bit errors in ASM
    tagname: '"packet_len"'
    threshold: '2'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    comment: Convert 0/1 bytes to float for Viterbi
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'Scale: 0/1 → 0/2'
    const: '2'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: 'Shift: 0/2 → -1/+1 soft symbols'
    const: '-1'
    type: float
  states: {}
- name: fec_decode_ccsds_27_fb_0
  id: fec_decode_ccsds_27_fb
  parameters:
    comment: Viterbi decoder r=1/2 k=7 — 4080 soft → 255 bytes
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    comment: RS(255,223) decode — corrects up to 16 symbol errors
    interleave: '1'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Decoded data output — 223 bytes per frame
    file: /tmp/gfsk_rx_decoded.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: RX Signal
    name: '"RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: '"RX Waterfall"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: '"blue"'
    comment: Shows demodulated bits — verify signal is present
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Demod Bits
    name: '"Demodulated Bits"'
    size: '2048'
    srate: samp_rate/sps
    stem_plot: 'False'
    tr_level: '0.5'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    comment: For time sink display
    scale: '1'
  states: {}

connections:
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', fec_decode_ccsds_27_fb_0, '0']
- [fec_decode_ccsds_27_fb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_decode_rs_ccsds_0, in]
- [satellites_decode_rs_ccsds_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
