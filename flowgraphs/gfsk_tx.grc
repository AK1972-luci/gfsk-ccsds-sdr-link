options:
  parameters:
    author: 'AK '
    category: Custom
    description: GFSK Transmitter for USRP B200 — CCSDS compatible
    generate_options: qt_gui
    id: gfsk_tx
    output_language: python
    realtime_scheduling: '1'
    title: GFSK Transmitter - USRP B200
  states: {}

blocks:
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: USRP B200 sample rate — baud = 384000/40 = 9600
    value: '384000'
  states: {}
- name: sps
  id: variable
  parameters:
    comment: Samples per symbol — baud_rate = 384000/40 = 9600
    value: '40'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: TX center frequency
    value: 433e6
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    comment: h=0.6 → deviation = 0.6 * 9600 / 2 = 2880 Hz
    value: '2880'
  states: {}
- name: sensitivity
  id: variable
  parameters:
    comment: GFSK modulator/demodulator sensitivity
    value: 2 * math.pi * fsk_deviation / samp_rate
  states: {}
- name: encoded_frame_len
  id: variable
  parameters:
    comment: RS(255,223) + Conv r=1/2 → 255*2 = 510 packed bytes
    value: '510'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: TX Gain (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Test data — 223 bytes for RS(255,223) input
    repeat: 'True'
    type: byte
    vector: (list(b'ID:0000 SAT:3U-SAT-01 T:15:25:41 BAT:98% GPS:F\n') * 5)[:223]
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '223'
    type: byte
  states: {}
- name: epy_block_rs_encode
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      # Minimal CCSDS RS(255,223) encoder using ccsds_rs_encode
      try:
          from satellites import ccsds_rs
          HAS_SATELLITES = True
      except ImportError:
          HAS_SATELLITES = False

      GF_EXP = None
      GF_LOG = None
      GEN_POLY = None

      def _init_gf():
          global GF_EXP, GF_LOG, GEN_POLY
          if GF_EXP is not None:
              return
          GF_EXP = [0] * 512
          GF_LOG = [0] * 256
          x = 1
          for i in range(255):
              GF_EXP[i] = x
              GF_LOG[x] = i
              x <<= 1
              if x & 0x100:
                  x ^= 0x187  # CCSDS polynomial x^8+x^7+x^2+x+1
          for i in range(255, 512):
              GF_EXP[i] = GF_EXP[i - 255]
          # Build generator polynomial for t=16 (32 parity symbols)
          # roots are alpha^(112+i) for i in 0..31  (CCSDS dual-basis)
          GEN_POLY = [0] * 33
          GEN_POLY[0] = 1
          for i in range(32):
              root = GF_EXP[112 + i]
              for j in range(i + 1, 0, -1):
                  if GEN_POLY[j - 1] != 0:
                      GEN_POLY[j] ^= GF_EXP[(GF_LOG[GEN_POLY[j - 1]] + GF_LOG[root]) % 255]
                  else:
                      GEN_POLY[j] = GEN_POLY[j]
              GEN_POLY[0] = GF_EXP[(GF_LOG[GEN_POLY[0]] + GF_LOG[root]) % 255]

      def _gf_mul(a, b):
          if a == 0 or b == 0:
              return 0
          return GF_EXP[GF_LOG[a] + GF_LOG[b]]

      # CCSDS dual-basis lookup tables
      BERLEKAMP_TO_CONVENTIONAL = [
          0x00,0x7b,0x09,0x72,0x12,0x69,0x1b,0x60,0x24,0x5f,0x2d,0x56,0x36,0x4d,0x3f,0x44,
          0x48,0x33,0x41,0x3a,0x5a,0x21,0x53,0x28,0x6c,0x17,0x65,0x1e,0x7e,0x05,0x77,0x0c,
          0x90,0xeb,0x99,0xe2,0x82,0xf9,0x8b,0xf0,0xb4,0xcf,0xbd,0xc6,0xa6,0xdd,0xaf,0xd4,
          0xd8,0xa3,0xd1,0xaa,0xca,0xb1,0xc3,0xb8,0xfc,0x87,0xf5,0x8e,0xee,0x95,0xe7,0x9c,
          0xf6,0x8d,0xff,0x84,0xe4,0x9f,0xed,0x96,0xd2,0xa9,0xdb,0xa0,0xc0,0xbb,0xc9,0xb2,
          0xbe,0xc5,0xb7,0xcc,0xac,0xd7,0xa5,0xde,0x9a,0xe1,0x93,0xe8,0x88,0xf3,0x81,0xfa,
          0x66,0x1d,0x6f,0x14,0x74,0x0f,0x7d,0x06,0x42,0x39,0x4b,0x30,0x50,0x2b,0x59,0x22,
          0x2e,0x55,0x27,0x5c,0x3c,0x47,0x35,0x4e,0x0a,0x71,0x03,0x78,0x18,0x63,0x11,0x6a,
          0x31,0x4a,0x38,0x43,0x23,0x58,0x2a,0x51,0x15,0x6e,0x1c,0x67,0x07,0x7c,0x0e,0x75,
          0x79,0x02,0x70,0x0b,0x6b,0x10,0x62,0x19,0x5d,0x26,0x54,0x2f,0x4f,0x34,0x46,0x3d,
          0xa1,0xda,0xa8,0xd3,0xb3,0xc8,0xba,0xc1,0x85,0xfe,0x8c,0xf7,0x97,0xec,0x9e,0xe5,
          0xe9,0x92,0xe0,0x9b,0xfb,0x80,0xf2,0x89,0xcd,0xb6,0xc4,0xbf,0xdf,0xa4,0xd6,0xad,
          0xc7,0xbc,0xce,0xb5,0xd5,0xae,0xdc,0xa7,0xe3,0x98,0xea,0x91,0xf1,0x8a,0xf8,0x83,
          0x8f,0xf4,0x86,0xfd,0x9d,0xe6,0x94,0xef,0xab,0xd0,0xa2,0xd9,0xb9,0xc2,0xb0,0xcb,
          0x57,0x2c,0x5e,0x25,0x45,0x3e,0x4c,0x37,0x73,0x08,0x7a,0x01,0x61,0x1a,0x68,0x13,
          0x1f,0x64,0x16,0x6d,0x0d,0x76,0x04,0x7f,0x3b,0x40,0x32,0x49,0x29,0x52,0x20,0x5b
      ]
      CONVENTIONAL_TO_BERLEKAMP = [0] * 256
      for _i in range(256):
          CONVENTIONAL_TO_BERLEKAMP[BERLEKAMP_TO_CONVENTIONAL[_i]] = _i

      def _rs_encode_ccsds(data_223):
          """Encode 223 bytes with CCSDS RS(255,223). Returns 255 bytes."""
          _init_gf()
          # Convert from conventional to dual basis
          conv_data = [CONVENTIONAL_TO_BERLEKAMP[b] for b in data_223]
          # Compute parity in dual basis
          parity = [0] * 32
          for i in range(223):
              feedback = conv_data[i] ^ parity[0]
              for j in range(31):
                  if GEN_POLY[31 - j] != 0 and feedback != 0:
                      parity[j] = parity[j + 1] ^ GF_EXP[GF_LOG[GEN_POLY[31 - j]] + GF_LOG[feedback]]
                  else:
                      parity[j] = parity[j + 1]
              if GEN_POLY[0] != 0 and feedback != 0:
                  parity[31] = GF_EXP[GF_LOG[GEN_POLY[0]] + GF_LOG[feedback]]
              else:
                  parity[31] = 0
          # Convert parity back to conventional basis
          parity_conv = [BERLEKAMP_TO_CONVENTIONAL[p] for p in parity]
          return list(data_223) + parity_conv

      class rs_encode_vector(gr.basic_block):
          """RS(255,223) CCSDS encoder: takes 223-byte vectors, outputs 255-byte vectors.
          Uses gr-satellites if available, otherwise pure-Python fallback."""
          def __init__(self):
              gr.basic_block.__init__(self,
                  name='RS Encode CCSDS',
                  in_sig=[(np.uint8, 223)],
                  out_sig=[(np.uint8, 255)])

          def general_work(self, input_items, output_items):
              n = min(len(input_items[0]), len(output_items[0]))
              if n == 0:
                  return 0
              for i in range(n):
                  data = input_items[0][i].tolist()
                  if HAS_SATELLITES:
                      encoded = list(data) + [0]*32
                      ccsds_rs.encode(encoded)
                      output_items[0][i] = np.array(encoded, dtype=np.uint8)
                  else:
                      output_items[0][i] = np.array(_rs_encode_ccsds(data), dtype=np.uint8)
              self.consume(0, n)
              return n
    comment: RS(255,223) — adds 32 parity bytes (no external dependency)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '255'
    type: byte
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters:
    comment: Conv. encoder r=1/2 k=7 — doubles bitstream
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Pack unpacked bits to bytes (510 bytes per frame)
    k: '8'
  states: {}
- name: epy_block_asm_prepend
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class asm_prepend(gr.basic_block):
          """Prepends CCSDS ASM (0x1ACFFC1D) to every frame_len-byte frame."""
          def __init__(self, frame_len=510):
              gr.basic_block.__init__(self,
                  name='ASM Prepend',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.frame_len = frame_len
              self.asm = np.array([0xD8, 0x71, 0x12, 0xBD], dtype=np.uint8)

          def forecast(self, noutput_items, ninputs):
              n_frames = max(1, noutput_items // (self.frame_len + 4))
              return [n_frames * self.frame_len]

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n_frames = min(len(inp) // self.frame_len, len(out) // (self.frame_len + 4))
              if n_frames == 0:
                  return 0
              idx_out = 0
              for i in range(n_frames):
                  out[idx_out:idx_out+4] = self.asm
                  idx_out += 4
                  start = i * self.frame_len
                  out[idx_out:idx_out+self.frame_len] = inp[start:start+self.frame_len]
                  idx_out += self.frame_len
              self.consume(0, n_frames * self.frame_len)
              return idx_out
    comment: Prepends 4-byte custom ASM (0xD87112BD) to every 510-byte encoded frame
    frame_len: encoded_frame_len
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    comment: GFSK modulator — h=1.5, BT=0.35
    samples_per_symbol: sps
    sensitivity: sensitivity
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: ''
    center_freq0: center_freq
    clock_rate: '0.0'
    comment: USRP B200 TX
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: TX Spectrum — see occupied bandwidth
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: '[1,0,1,1]'
    label1: TX Signal
    name: '"TX Spectrum"'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_rs_encode, '0']
- [epy_block_rs_encode, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', fec_encode_ccsds_27_bb_0, '0']
- [fec_encode_ccsds_27_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_asm_prepend, '0']
- [epy_block_asm_prepend, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', uhd_usrp_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
